Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_Ceramica-Catalano_SFERA-52x35-Floorstanding-Silentech-WC.ifc
Time: 2024-04-29T11:44:01
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: SFERA 52x35 Floorstanding Silentech WC
ePset_BIMobjectScript - SEAT_COVER_WC: SLIM_SOFT_CLOSE; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): SFERA 52x35 Floorstanding Silentech WC; SKU (BO_prodsku): SFERA_wc_terra_52x35_0512420001; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): https://www.catalano.it/; ProductFamily (BO_prodfam): Sfera; ProductGroup (BO_prodgroup): WC; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 350; Height (BO_height): 410; Depth (BO_depth): 520; Weight (BO_weight): 28; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/SFERA_wc_terra_52x35_0512420001; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/SFERA_wc_terra_52x35_0512420001; ProductUrl (BO_producturl): https://www.catalano.it/prodotti/vaso-sfera-52/; InstallationInstructions (BO_montins): https://www.youtube.com/watch?v=GsoSS3JYD00; TechnicalDescription (BO_techcert): http://www.ceramicacatalano.it/allegati_schede/schede-tecniche/SFERA/WC_Sfera_52x35_05%201242%200001_IT.pdf; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=vjmBK4DxDCM; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Vitreous china; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass2015Code (BO_uniclass2015_code): SL_35_80_89; Uniclass2015Description (BO_uniclass2015_desc): Toilets; OmniClassCode (BO_omniclass_code): 23-31 19 00; OmniClassDescription (BO_omniclass_name): Toilets; MasterFormat2014Code (BO_masterformat2014_code): 22 41 13.13; MasterFormat2014Description (BO_masterformat2014_name): Residential Water Closets; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
